Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: R LUM 10.220.1200.IFC
Time: 2023-12-11T11:20:25
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: R LUM 10.220.1200
In: Default Storey
SolidWorks Custom Properties - Description: R LUM 10.220.1200
PSet_Mass_Property - Mass Measure: 1.76765; Area Measure: 0.106004 m2; Volume Measure: 0.00176765 m3
