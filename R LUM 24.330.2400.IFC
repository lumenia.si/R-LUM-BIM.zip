Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: R LUM 24.330.2400.IFC
Time: 2023-12-11T11:22:00
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: R LUM 24.330.2400
In: Default Storey
SolidWorks Custom Properties - Description: R LUM 24.330.2400
PSet_Mass_Property - Mass Measure: 273172139; Area Measure: 0; Volume Measure: 0.00415463 m3
