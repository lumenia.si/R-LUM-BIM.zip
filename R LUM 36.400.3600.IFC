Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: R LUM 36.400.3600.IFC
Time: 2023-12-11T11:22:32
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: R LUM 36.400.3600
In: Default Storey
SolidWorks Custom Properties - Description: R LUM 36.400.3600
PSet_Mass_Property - Mass Measure: 6.19678; Area Measure: 0.30747 m2; Volume Measure: 0.00619678 m3
